## boards/shields/atreus2tap/Kconfig.defconfig
```kconfig
if SHIELD_ATREUS2TAP

config ZMK_KEYBOARD_NAME
    default "atreus2tap"

endif # SHIELD_ATREUS2TAP
```
